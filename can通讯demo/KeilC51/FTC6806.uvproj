# Keil uVision project FTC6806.uvproj, settings and files
target FU6366_MR (MCS-51)
  device: FU6866 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FU6366_MR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\include;..\FU68xx_Hardware_Driver\include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/: main.c Interrupt.c FocControl.c SensorFunction.c AddFunction.c ApplyFunction.c ControlChat.c
    ../User/include/: Customer.h Protect.h Parameter.h
  group Function
    ../User/source/: FocControlFunction.c SystermInit.c FlashWrite.c Protect.c ServoControl.c
    ../FU68xx_Hardware_Driver/source/: STARTUP_FU6816.A51
  group HardWare
    ../FU68xx_Hardware_Driver/source/: ADC.c AMP.c CMP.c CRC.c DMA.c DRIVER.c EXTIInit.c GPIO.c MDUInit.c PIInit.c SPI.c UART.c CAN.c
